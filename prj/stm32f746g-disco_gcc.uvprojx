# Keil uVision project stm32f746g-disco_gcc.uvprojx, settings and files
target STM32F746G-DISCO (ARM-GNU)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: ..\bin\fw.elf
  AfterMake: arm-none-eabi-size ..\bin\fw.elf
  group board
    ../src/: board.c board_heap_table.h main.c
  group framework
    ../../../framework/utils/: strutils.c heap.c memory.c
    ../../../framework/hal/stm32f7/: clock.c dma.c gpio.c irq.c mcu.c uart.c spi.c emc.c
    ../../../framework/os/: irq-core.c osfunc.c startup.c
    ../../../framework/hal/common/: svcall.c systick.c
  group drivers
    ../../../framework/drivers/console/: console_serial.c
    ../../../framework/drivers/display/: display.c rk043fn48h.c
